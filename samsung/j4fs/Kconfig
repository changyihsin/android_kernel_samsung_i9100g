## samsung/j4fs/Kconfig
```kconfig
config J4FS
	tristate "Samsung J4FS support"
	default m
	help
	  Say Y to enable Samsung J4FS support.
```
